# Keil uVision project MPU_TEST.uvproj, settings and files
target Cortex-M0 SDK - Simulator (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Simple_Code +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --c99 --thumb -c
  c include: .\..\dk_apps\src\plf\refip\src\driver\i2c_eeprom;.\..\dk_apps\src\plf\refip\src\driver\spi;.\..\dk_apps\src\plf\refip\src\arch;.\..\dk_apps\src\plf\refip\src\arch\compiler\rvds;.\..\dk_apps\src\plf\refip\src\arch\ll\rvds;.\..\dk_apps\src\plf\refip\src\driver\reg;.\..\dk_apps\src\dialog\include;.\include;.\..\dk_apps\src\plf\refip\src\driver\gpio;.\..\dk_apps\src\plf\refip\src\driver\adc;.\..\dk_apps\src\plf\refip\src\driver\battery;.\..\dk_apps\src\plf\refip\src\driver\spi_flash;.\..\dk_apps\src\modules\app\api;.\..\dk_apps\src\ip\ble\hl\src\rwble_hl;..\dk_apps\src\plf\refip\src\driver\wkupct_quadec;..\dk_apps\src\plf\refip\src\driver\pwm;.\eMPL
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x2800
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./src/: peripherals.c main.c
  group I2C
    ./src/: i2c_eeprom.c i2c_func.c
  group gpio
    ./src/: gpio.c gpio_func.c
  group uart
    ./src/: uart.c uart_func.c
  group dmp
    ./eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c motion.c
