# Keil uVision project HR_TEST.uvproj, settings and files
target Cortex-M0 SDK - Simulator (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Simple_Code +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --c99 --thumb -c
  c include: .\..\dk_apps\src\plf\refip\src\arch;.\..\dk_apps\src\plf\refip\src\arch\compiler\rvds;.\..\dk_apps\src\plf\refip\src\arch\ll\rvds;.\..\dk_apps\src\plf\refip\src\driver\reg;.\..\dk_apps\src\dialog\include;.\include;.\..\dk_apps\src\plf\refip\src\driver\gpio;.\..\dk_apps\src\modules\app\api;.\..\dk_apps\src\ip\ble\hl\src\rwble_hl;..\dk_apps\src\plf\refip\src\driver\wkupct_quadec
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x2800
  group Startup Files
    ./startup/: startup_CMSDK_CM0.s system_CMSDK.c
  group Source Files
    ./src/: peripherals.c main.c gpio.c spi.c pwm.c
